# Keil uVision project at32f415rc_can.uvprojx, settings and files
target at32f415rc_can (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415RCT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.1.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: at32f415rc_can
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F415RCT7,USE_STDPERIPH_DRIVER,AT_START_F415_V1
  c include: ..\AT32F415_Firmware_Library\libraries\drivers\inc;..\AT32F415_Firmware_Library\libraries\cmsis\cm4\core_support;..\AT32F415_Firmware_Library\libraries\cmsis\cm4\device_support;..\examples\at32f415rc_can\;..\AT32F415_Firmware_Library\project\at32f415_board;..\CANopenNode_AT32;..\CANopenNode
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group user
    ../examples/at32f415rc_can/: startup_at32f415.s at32f415_clock.c at32f415_int.c main.c
  group bsp
    ../AT32F415_Firmware_Library/project/at32f415_board/: at32f415_board.c
  group firmware
    ../AT32F415_Firmware_Library/libraries/drivers/src/: at32f415_gpio.c at32f415_crm.c at32f415_usart.c at32f415_can.c at32f415_misc.c at32f415_tmr.c at32f415_usb.c
  group cmsis
    ../AT32F415_Firmware_Library/libraries/cmsis/cm4/device_support/: system_at32f415.c
  group CANopenNode_AT32
    ../CANopenNode_AT32/: CO_driver_target.h CO_app_AT32.c CO_driver_AT32.c CO_storageBlank.c OD.c
  group CANopenNode
    ../CANopenNode/: CANopen.c
  group CANopenNode/301
    ../CANopenNode/301/: CO_Emergency.c CO_fifo.c CO_HBconsumer.c CO_NMT_Heartbeat.c CO_Node_Guarding.c CO_ODinterface.c CO_PDO.c CO_SDOclient.c CO_SDOserver.c CO_SYNC.c CO_TIME.c crc16-ccitt.c
  group CANopenNode/303
    ../CANopenNode/303/: CO_LEDs.c
  group CANopenNode/304
    ../CANopenNode/304/: CO_GFC.c CO_SRDO.c
  group CANopenNode/305
    ../CANopenNode/305/: CO_LSSmaster.c CO_LSSslave.c
